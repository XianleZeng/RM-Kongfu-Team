# Keil uVision project Kongfu-Sentry.uvprojx, settings and files
target Kongfu-Sentry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Kongfu-Sentry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../applications;../bsp/boards;../User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group boards
    ../bsp/boards/: bsp_rc.c bsp_rc.h bsp_usart.c bsp_usart.h struct_typedef.h bsp_can.c bsp_can.h
  group User
    ../User/1_Middleware/1_Driver/BSP/: drv_bsp.c drv_bsp.h
    ../User/1_Middleware/1_Driver/Math/: drv_math.cpp drv_math.h
    ../User/1_Middleware/1_Driver/UART/: drv_uart.c drv_uart.h
    ../User/1_Middleware/2_Algorithm/PID/: alg_pid.cpp alg_pid.h
    ../User/2_Device/Remote_control/: remote_control.c remote_control.h
    ../User/2_Device/Serialplot/: dvc_serialplot.cpp dvc_serialplot.h
    ../User/1_Middleware/1_Driver/CAN/: drv_CAN_receive.c drv_CAN_receive.h
    ../User/2_Device/Motor/: dvc_motor.h dvc_motor.cpp
  group Task
    ../User/Task/: tsk_config_and_callback.cpp tsk_config_and_callback.h
software components: CMSIS:CORE 4.3.0
